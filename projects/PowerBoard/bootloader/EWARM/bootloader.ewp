# IAR project bootloader.ewp, settings and files
configuration POWERBOARD_STM32F103ZE (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F103xE; xSIZE_OPTIMIZE; BOOTLOADER; NO_MICO_RTOS; MICO_DISABLE_WATCHDOG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\platforms\MCUs\STM32F1xx; ..\..\..\..\board; ..\..\..\..\kernel\RTOS\NoRTOS; ..\..\..\..\bootloader; ..\..\..\..\platforms\MCUs\STM32F1xx\EWARM; ..\..\..\..\platforms\Cortex-M3\CMSIS\Include; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries; ..\..\..\..\platforms\Cortex-M3\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\platforms\include; ..\..\..\..\include; ..\..\..\..\include\MiCODrivers; ..\..\..\..\board\PowerBoard_V2; ..\..\..\..\platforms\Cortex-M3; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals; ..\..\..\..\library\utilities; ..\..\..\..\kernel\security\Curve25519; ..\..\..\..\kernel\security
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.hex
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: ..\..\..\..\board\PowerBoard_V2\bootloaderLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration POWERBOARD_STM32F103RB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_FULL_ASSERT; STM32F103xB; xSIZE_OPTIMIZE; BOOTLOADER; NO_MICO_RTOS; MICO_DISABLE_WATCHDOG
  ICCARM.CCIncludePath2: ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\platforms\MCUs\STM32F1xx; ..\..\..\..\board; ..\..\..\..\kernel\RTOS\NoRTOS; ..\..\..\..\bootloader; ..\..\..\..\platforms\MCUs\STM32F1xx\EWARM; ..\..\..\..\platforms\Cortex-M3\CMSIS\Include; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries; ..\..\..\..\platforms\Cortex-M3\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\platforms\include; ..\..\..\..\include; ..\..\..\..\include\MiCODrivers; ..\..\..\..\board\PowerBoard; ..\..\..\..\platforms\Cortex-M3; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals; ..\..\..\..\library\utilities; ..\..\..\..\kernel\security\Curve25519; ..\..\..\..\kernel\security
  ILINK.IlinkIcfFile: ..\..\..\..\board\PowerBoard\bootloaderLinkerForIAR.icf
configuration Carson_PB_STM32F103ZE_Master (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\platforms\MCUs\STM32F1xx; ..\..\..\..\kernel\RTOS\NoRTOS; ..\..\..\..\bootloader; ..\..\..\..\platforms\MCUs\STM32F1xx\EWARM; ..\..\..\..\platforms\Cortex-M3\CMSIS\Include; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals\libraries; ..\..\..\..\platforms\Cortex-M3\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\platforms\include; ..\..\..\..\include; ..\..\..\..\include\MiCODrivers; ..\..\..\..\board\PowerBoard_Carson_Master; ..\..\..\..\platforms\Cortex-M3; ..\..\..\..\platforms\MCUs\STM32F1xx\peripherals; ..\..\..\..\library\utilities; ..\..\..\..\kernel\security\Curve25519; ..\..\..\..\kernel\security
  ILINK.IlinkIcfFile: ..\..\..\..\board\PowerBoard_Carson_Master\bootloaderLinkerForIAR.icf
  group Board/Carson_PB_Master
    ../../../../board/PowerBoard_Carson_Master/: platform.c platform.h platform_config.h
  group Board/PowerBoard
    ../../../../board/PowerBoard/: platform.c platform.h platform_config.h
  group Board/PowerBoard_V2
    ../../../../board/PowerBoard_V2/: platform.c platform.h platform_config.h
  group Bootloader
    ../../../../bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
  group include
    ../../../../include/: common.h debug.h mico.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h MiCOSRPServer.h
  group include/MicoDriver
    ../../../../include/MiCODrivers/: MiCODriverAdc.h MiCODriverCan.h MiCODriverFlash.h MiCODriverGpio.h MiCODriverI2c.h MiCODriverMFiAuth.h MiCODriverNanoSecond.h MiCODriverPwm.h MiCODriverRng.h MiCODriverRtc.h MiCODriverSpi.h MiCODriverUart.h MiCODriverWdg.h
  group kernel
    ../../../../kernel/RTOS/NoRTOS/: rtos.c
  group libraries/utilities
    ../../../../library/utilities/: AESUtils.c AESUtils.h CheckSumUtils.c CheckSumUtils.h RingBufferUtils.c RingBufferUtils.h SecurityUtils.c SecurityUtils.h StringUtils.c StringUtils.h TLVUtils.c TLVUtils.h URLUtils.c URLUtils.h
  group Platform/Cortex-M3
    ../../../../platforms/Cortex-M3/: crt0_EWARM.c hardfault.c
  group Platform/EWARM
    ../../../../platforms/EWARM/: Retarget.c
  group Platform/MCU/STM32F1xx
    ../../../../platforms/MCUs/: mico_platform_common.c
    ../../../../platforms/MCUs/STM32F1xx/: platform_init.c
  group Platform/MCU/STM32F1xx/EWARM
    ../../../../board/PowerBoard_V2/: bootloaderLinkerForIAR.icf
    ../../../../platforms/MCUs/STM32F1xx/EWARM/: startup_stm32f103xb_bootloader_EWARM.s startup_stm32f103xe_bootloader_EWARM.s
  group Platform/MCU/STM32F1xx/Peripherals
    ../../../../platforms/MCUs/STM32F1xx/peripherals/: platform_can.c platform_flash.c platform_gpio.c platform_mcu_peripheral.h platform_mcu_powersave.c platform_uart.c platform_watchdog.c
  group Platform/MCU/STM32F1xx/Peripherals/Libraries
    ../../../../platforms/MCUs/STM32F1xx/peripherals/libraries/: stm32f1xx_hal_conf.h system_stm32f1xx.c
  group Platform/MCU/STM32F1xx/Peripherals/Libraries/STM32F1xx_HAL_Drivers
    ../../../../platforms/MCUs/STM32F1xx/peripherals/libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
