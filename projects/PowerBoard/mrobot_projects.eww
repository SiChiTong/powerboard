<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bootloader\EWARM\bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\application\EWARM\PowerBoard_Application.ewp</path>
  </project>
  <batchBuild/>
</workspace>


